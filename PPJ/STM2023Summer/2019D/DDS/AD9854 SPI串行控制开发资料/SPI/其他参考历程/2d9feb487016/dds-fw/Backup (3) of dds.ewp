# IAR project Backup (3) of dds.ewp, settings and files
configuration Debug (MSP430, debug)
  ICC430.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk430F149.xcl
configuration Release (MSP430)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: MSP430-fw-console.c MSP430-fw-dds[1].c MSP430-fw-hamtables.c MSP430-fw-interrupts.c MSP430-fw-lcd.c MSP430-fw-main.c MSP430-fw-memory.c
