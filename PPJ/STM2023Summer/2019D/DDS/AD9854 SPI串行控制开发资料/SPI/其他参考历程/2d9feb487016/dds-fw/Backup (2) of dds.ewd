<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>1</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>3</archiveVersion>
      <data>
        <version>13</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>Driver</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>IProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>MemOverride</name>
          <state>1</state>
        </option>
        <option>
          <name>Port</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Baud</name>
          <version>0</version>
          <state>1</state>
        </option>
        <option>
          <name>Parity</name>
          <version>0</version>
          <state>1</state>
        </option>
        <option>
          <name>DataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>StopBits</name>
          <version>0</version>
          <state>1</state>
        </option>
        <option>
          <name>Handshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>DoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>LogFile</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>PortParallel</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllCommParallel</name>
          <state>1</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMRemapReset</name>
          <state>1</state>
        </option>
        <option>
          <name>ROMBurnEPROM</name>
          <state>1</state>
        </option>
        <option>
          <name>ROMMonitorDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMBurnResetVector</name>
          <state>0</state>
        </option>
        <option>
          <name>GoToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>GoToName</name>
          <state>main</state>
        </option>
        <option>
          <name>Erase</name>
          <state>1</state>
        </option>
        <option>
          <name>EMUVerifyDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMVerifyDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUAskSuppress</name>
          <state>0</state>
        </option>
        <option>
          <name>EraseOptionSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>DdfFile</name>
          <state>$TOOLKIT_DIR$\config\msp430C111.ddf</state>
        </option>
        <option>
          <name>VirtualBreakpoint</name>
          <state>0</state>
        </option>
        <option>
          <name>ExitBreakpoint</name>
          <state>0</state>
        </option>
        <option>
          <name>PutcharBreakpoint</name>
          <state>1</state>
        </option>
        <option>
          <name>GetcharBreakpoint</name>
          <state>1</state>
        </option>
        <option>
          <name>derivative</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>3</archiveVersion>
      <data>
        <version>13</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>Driver</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>IProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>MemOverride</name>
          <state>1</state>
        </option>
        <option>
          <name>Port</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Baud</name>
          <version>0</version>
          <state>1</state>
        </option>
        <option>
          <name>Parity</name>
          <version>0</version>
          <state>1</state>
        </option>
        <option>
          <name>DataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>StopBits</name>
          <version>0</version>
          <state>1</state>
        </option>
        <option>
          <name>Handshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>DoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>LogFile</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>PortParallel</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllCommParallel</name>
          <state>1</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMRemapReset</name>
          <state>1</state>
        </option>
        <option>
          <name>ROMBurnEPROM</name>
          <state>1</state>
        </option>
        <option>
          <name>ROMMonitorDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMBurnResetVector</name>
          <state>0</state>
        </option>
        <option>
          <name>GoToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>GoToName</name>
          <state>main</state>
        </option>
        <option>
          <name>Erase</name>
          <state>1</state>
        </option>
        <option>
          <name>EMUVerifyDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMVerifyDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUAskSuppress</name>
          <state>0</state>
        </option>
        <option>
          <name>EraseOptionSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>DdfFile</name>
          <state></state>
        </option>
        <option>
          <name>VirtualBreakpoint</name>
          <state>0</state>
        </option>
        <option>
          <name>ExitBreakpoint</name>
          <state>0</state>
        </option>
        <option>
          <name>PutcharBreakpoint</name>
          <state>1</state>
        </option>
        <option>
          <name>GetcharBreakpoint</name>
          <state>1</state>
        </option>
        <option>
          <name>derivative</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
</project>


