# IAR project dds.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XlinkStackSize: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk430F149.xcl
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: MSP430C111 MSP430C111
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: MSP430-fw-console.c MSP430-fw-dds[1].c MSP430-fw-hamtables.c MSP430-fw-interrupts.c MSP430-fw-lcd.c MSP430-fw-main.c MSP430-fw-memory.c
