# Keil uVision project MSP432.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MSP432
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX keil
  c include: ..\Library;..\Basic\Delay;..\Basic;..\Basic\SystemInit;..\Hardware\LED;..\Library;..\Hardware\OLED;..\Basic\RTC;..\Hardware\Button;..\Basic\Usart;..\CMSIS\5.7.0\CMSIS\DSP\Include;..\CMSIS\5.7.0\CMSIS\Include;..\Basic\ADC;..\User;..\Basic\DMA;..\Basic\Process;..\Basic\WIRELESS;..\Basic\key
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group User
    ../User/: main.c
  group Basic
    ../Basic/Delay/: delay.c
    ../Basic/SystemInit/: SystemInit.c
    ../Basic/Usart/: usart.c
    ../Basic/ADC/: adc.c
    ../Basic/DMA/: dma.c
    ../Basic/Process/: measure.c
    ../Basic/WIRELESS/: esp8266.c
    ../Basic/key/: my_key.c
  group Library
    ../Library/: msp432p4xx_driverlib.lib
    ../CMSIS/5.7.0/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
    ../CMSIS/5.7.0/CMSIS/DSP/Source/TransformFunctions/: arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
software components: CMSIS:CORE 5.1.1, Device:Startup 3.2.2
